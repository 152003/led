# Keil uVision project led.uvprojx, settings and files
target led (ARM-ADS)
  device: STM32MP157AAAx:Cortex-M4 STMicroelectronics
  cpu: IRAM(0x10020000-0x1003FFFF) IRAM2(0x10040000-0x1005FFFF) IROM(0x10000000-0x1001FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: led +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32MP157Axx
  c include: ../CM4/Inc;../Drivers/STM32MP1xx_HAL_Driver/Inc;../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32MP1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  scatter file: stm32mp15xx_m4.sct
  group Application/MDK-ARM
    ./: startup_stm32mp15xx_CM4.s
  group Application/User/CM4
    ../CM4/Src/: main.c stm32mp1xx_it.c stm32mp1xx_hal_msp.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal.c stm32mp1xx_hal_exti.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32mp1xx.c
software components: CMSIS:CORE 4.3.0
